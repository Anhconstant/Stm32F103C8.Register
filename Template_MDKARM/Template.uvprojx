# Keil uVision project Template.uvprojx, settings and files
target Template (5060960::V5.06 update 7 (build 960)::.\ARM_Compiler_5.06u7)
  device: STM32F103C8 STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.4.1
  cpu: IRAM(0x20000000,0x00005000) IROM(0x08000000,0x00010000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: Template +hex
  c flags: Optim=1 OneElfS=1 uC99=1 uGnu=1 v6Lang=1 v6LangP=1 wLevel=2
  c include: .\Inc;.\CMSIS\Include;.\device
  memory RVCT4: ROM 0x8000000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x5000
  group Source
    ./Src/: debug.c delay.c stm32_gpio.c stm32_i2c.c stm32_led7seg.c stm32_rcc.c stm32_spi.c stm32_systick.c stm32_uart.c
    ./device/: main.c stm32f1xx.h system_stm32f1xx.h
  group Startup
    ./device/: startup_stm32f103xb.s
