# Keil uVision project Template.uvprojx, settings and files
target Template (5060960::V5.06 update 7 (build 960)::.\ARM_Compiler_5.06u7)
  device: STM32F103C8 STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.4.1
  cpu: IRAM(0x20000000,0x00005000) IROM(0x08000000,0x00010000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: Template +hex
  c flags: Optim=1 OneElfS=1 uC99=1 uGnu=1 v6Lang=1 v6LangP=1 wLevel=2
  c include: .\Source;.\Core\Include;.\Core\Startup;.\Core\Source
  memory RVCT4: ROM 0x8000000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x5000
  group Source
    ./Core/Source/: main.c stm32_delay.c stm32_gpio.c stm32_gptim.c stm32_rcc.c
  group Include
    ./Core/Include/: stm32_btim.h stm32_delay.h stm32_flash.h stm32_gpio.h stm32_gptim.h stm32_rcc.h stm32_systick.h stm32f1xx.h system_stm32f1xx.h
  group Startup
    ./Core/Startup/: startup_stm32f103xb.s
